# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Stm32f4Project;.\CMSIS\inc;.\Code\inc;.\StdLibrary\inc;.\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c
  group Code
    ./Code/src/: main.c
  group Startup
    ./Startup/: startup_stm32f40xx.s
  group StdLibrary
    ./StdLibrary/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
